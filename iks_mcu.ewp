# IAR project iks_mcu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE1 Milandr MDR1986VE1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 36
  General.FPU2: 0
  ICCARM.CCDefines: offDEBUG_ERR_CONSOLE_ON; offDEBUG_WAR_CONSOLE_ON
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: src; CMSIS\CM1\CoreSupport\; CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc\; startup\iar\; MDR32F9Qx_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iks_mcu.srec
  ILINK.IlinkOutputFile: iks_mcu - Debug.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE1\MDR1986VE1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: src; CMSIS\CM1\CoreSupport\; CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc\; startup\iar\; MDR32F9Qx_StdPeriph_Driver\inc\; CanFestival\include; CanFestival\include\MDR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: iks_mcu - Release.out
  ILINK.IlinkIcfFile: config\linker\Milandr\MDR1986VE1T\MDR1986VE1T.icf
  group CMSIS/CM1/CoreSupport
    CMSIS/CM1/CoreSupport/: core_cm1.h core_cmFunc.h core_cmInstr.h
  group CMSIS/CM1/DeviceSupport
    CMSIS/CM1/DeviceSupport/MDR1986VE1T/inc/: MDR1986VE1T.h
  group MDR32F9Qx_StdPeriph_Driver/inc
    MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_adc.h MDR32F9Qx_arinc429r.h MDR32F9Qx_arinc429t.h MDR32F9Qx_audio.h MDR32F9Qx_bkp.h MDR32F9Qx_can.h MDR32F9Qx_comp.h MDR32F9Qx_dac.h MDR32F9Qx_dma.h MDR32F9Qx_ebc.h MDR32F9Qx_eeprom.h MDR32F9Qx_eth.h MDR32F9Qx_i2c.h MDR32F9Qx_iwdg.h MDR32F9Qx_keypad.h MDR32F9Qx_led.h MDR32F9Qx_lib.h MDR32F9Qx_mil_std_1553.h MDR32F9Qx_port.h MDR32F9Qx_power.h MDR32F9Qx_rst_clk.h MDR32F9Qx_ssp.h MDR32F9Qx_timer.h MDR32F9Qx_uart.h MDR32F9Qx_usb.h MDR32F9Qx_wwdg.h
  group MDR32F9Qx_StdPeriph_Driver/src
    MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_eth.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_mil_std_1553.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group src
    src/: EtherCAT_driver.c EtherCAT_driver.h main.c main.h MDR1986VE1T_IT.c MDR1986VE1T_IT.h MDR32F9Qx_config.h
  group startup
    startup/iar/: startup_MDR1986VE1T.s system_MDR1986VE1T.c system_MDR1986VE1T.h
